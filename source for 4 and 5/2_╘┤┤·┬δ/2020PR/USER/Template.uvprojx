# Keil uVision project Template.uvprojx, settings and files
target Template (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\USER;..\HARDWARE\LED;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\MODEL\chassis_driver;..\BSP\adc;..\BSP\beep;..\BSP\can1;..\BSP\bsp;..\BSP\can2;..\BSP\gyro;..\BSP\m3508;..\BSP\PID;..\BSP\robomodule;..\BSP\robot;..\ACTION\M3508_DRIVE;..\ACTION\moving;..\ACTION\romote;..\MODEL\global_location;..\MODEL\pstwo;..\ACTION\test;..\ACTION\information;..\ACTION\task;..\USER;..\ACTION\debug;..\BSP\time;..\BSP\GPIO;..\BSP\ak80;..\BSP\a80
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group BSP
    ../BSP/robot/: robot.c
    ../BSP/bsp/: bsp.c
    ../BSP/adc/: adc.c
    ../BSP/can1/: can1.c
    ../BSP/can2/: can2.c
    ../BSP/gyro/: gyro.c
    ../BSP/m3508/: m3508.c
    ../BSP/PID/: PID.c
    ../BSP/time/: time.c
    ../BSP/GPIO/: GPIO.c
    ../BSP/ak80/: ak80.c
    ../BSP/a80/: a80.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_tim.c stm32f4xx_sdio.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
  group MODEL
    ../MODEL/chassis_driver/: chassis_driver.c
    ../MODEL/global_location/: global_location.c
    ../MODEL/pstwo/: pstwo.c
  group ACTION
    ../ACTION/M3508_DRIVE/: m3508_drive.c
    ../ACTION/moving/: moving.c
    ../ACTION/test/: road.c
    ../ACTION/information/: information.c
    ../ACTION/task/: task.c
    ../ACTION/debug/: debug.c
